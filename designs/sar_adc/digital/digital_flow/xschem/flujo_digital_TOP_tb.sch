** sch_path: designs/sar_adc/digital/digital_flow/xschem/flujo_digital_TOP_tb.sch
**.subckt flujo_digital_TOP_tb
V2 VDD 0 {VDD}
V3 VSS 0 0
VCOMP Vcomp 0 PULSE(0 {VDD} {3.4*Tclk} 0.1n 0.1n {Ts/2} {Ts})
VCLK CLK 0 PULSE({VDD} 0 0 0.1n 0.1n {Tclk/2} {Tclk})
VSAM SAMP 0 PULSE(0 {VDD} 0 0.1n 0.1n {Tclk} {Ts})
x1 VDD CLK SAMP Vcomp SW0[8] SW0[7] SW0[6] SW0[5] SW0[4] SW0[3] SW0[2] SW0[1] SW0[0] B[9] B[8] B[7]
+ B[6] B[5] B[4] B[3] B[2] B[1] B[0] SW1[8] SW1[7] SW1[6] SW1[5] SW1[4] SW1[3] SW1[2] SW1[1] SW1[0] VSS
+ net1[8] net1[7] net1[6] net1[5] net1[4] net1[3] net1[2] net1[1] net1[0] net2[8] net2[7] net2[6] net2[5]
+ net2[4] net2[3] net2[2] net2[1] net2[0] sar_logic
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical



* Input parameters
.param VDD = 3.3
.param Fs = 5Meg
.param Ts = 1/Fs
.param Tclk = 1/(Fs*12)

.control
save all

* Variables
let Fs = 5Meg
let tstep = 1/(Fs*12*100)
let tstop = 1/Fs+50n


* Transient simulation
tran $&tstep $&tstop

let i_vdd = -i(V2)
let p_inst = -v(VDD)*i(V2)
** Plots
meas tran Iavg AVG i_vdd FROM=$&tstep TO=$&tstop
meas tran Pavg AVG p_inst FROM=$&tstep TO=$&tstop

*plot xREG.SAMPN xREG.SET

plot "sw0[0]" "sw0[1]"+4 "sw0[2]"+8 "sw0[3]"+12 "sw0[4]"+16 "sw0[5]"+20 "sw0[6]"+24 "sw0[7]"+28
+ "sw0[8]"+32 Vcomp+36 SAMP+40 CLK+44
plot "sw1[0]" "sw1[1]"+4 "sw1[2]"+8 "sw1[3]"+12 "sw1[4]"+16 "sw1[5]"+20 "sw1[6]"+24 "sw1[7]"+28
+ "sw1[8]"+32 Vcomp+36 SAMP+40 CLK+44
plot "B[0]" "B[1]"+4 "B[2]"+8 "B[3]"+12 "B[4]"+16 "B[5]"+20 "B[6]"+24 "B[7]"+28 "B[8]"+32 "B[9]"+36
+ Vcomp+40 SAMP+44 CLK+48
.endc


**** end user architecture code
**.ends

* expanding   symbol:  designs/sar_adc/digital/digital_flow/xschem/sar_logic.sym # of pins=10
** sym_path: designs/sar_adc/digital/digital_flow/xschem/sar_logic.sym
** sch_path: designs/sar_adc/digital/digital_flow/xschem/sar_logic.sch
.subckt sar_logic VDD CLK SAMP Vcomp SW0n[8] SW0n[7] SW0n[6] SW0n[5] SW0n[4] SW0n[3] SW0n[2] SW0n[1]
+ SW0n[0] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] SW1p[8] SW1p[7] SW1p[6] SW1p[5] SW1p[4] SW1p[3]
+ SW1p[2] SW1p[1] SW1p[0] VSS SW0p[8] SW0p[7] SW0p[6] SW0p[5] SW0p[4] SW0p[3] SW0p[2] SW0p[1] SW0p[0] SW1n[8]
+ SW1n[7] SW1n[6] SW1n[5] SW1n[4] SW1n[3] SW1n[2] SW1n[1] SW1n[0]
*.iopin VDD
*.iopin VSS
*.iopin SAMP
*.iopin CLK
*.iopin B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0]
*.iopin SW0n[8],SW0n[7],SW0n[6],SW0n[5],SW0n[4],SW0n[3],SW0n[2],SW0n[1],SW0n[0]
*.iopin SW1n[8],SW1n[7],SW1n[6],SW1n[5],SW1n[4],SW1n[3],SW1n[2],SW1n[1],SW1n[0]
*.iopin Vcomp
*.iopin SW0p[8],SW0p[7],SW0p[6],SW0p[5],SW0p[4],SW0p[3],SW0p[2],SW0p[1],SW0p[0]
*.iopin SW1p[8],SW1p[7],SW1p[6],SW1p[5],SW1p[4],SW1p[3],SW1p[2],SW1p[1],SW1p[0]
**** begin user architecture code

* ==========================================
* LVS READY - MÓDULO: SAR_LOGIC
* ==========================================

.SUBCKT gf180mcu_fd_sc_mcu7t5v0__antenna I VDD VNW VPW VSS
*D0 VPW I diode_nd2ps_06v0 AREA=0.2052p PJ=1.86u M=1
*D1 I VNW diode_pd2nw_06v0 AREA=0.2052p PJ=1.86u M=1
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_1 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=5.65e-07 L=5e-07
X_i_1 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_2 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_4 I Z VDD VNW VPW VSS
X_i_2_0 Z_neg I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_2_1 VSS I Z_neg VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_2 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_3 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3_0 Z_neg I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_3_1 VDD I Z_neg VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkbuf_1 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_0 Z Z_neg VSS VPW nfet_05v0 W=4.95e-07 L=6e-07
* The device in the netlist is split in half, suggesting a two-fingered
* FET, which this is not.  Modified by Tim E. Nov. 3, 2025 to properly
* match the layout.
* M_i_3 VDD I Z_neg VNW pfet_05v0 W=5.25e-07 L=5e-07
* M_i_3_0 VDD I Z_neg VNW pfet_05v0 W=5.25e-07 L=5e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=1.05e-06 L=5e-07
X_i_1 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkbuf_16 I Z VDD VNW VPW VSS
X_i_2_0 Z_neg I VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_1 VSS I Z_neg VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_2 Z_neg I VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_3 VSS I Z_neg VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_4 Z_neg I VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_5 VSS I Z_neg VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_2 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_3 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_4 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_5 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_6 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_7 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_8 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_9 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_10 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_11 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_12 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_13 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_14 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_15 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_3_0 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_1 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_2 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_3 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_4 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_5 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_6 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_7 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_4 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_5 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_6 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_7 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_8 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_9 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_10 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_11 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_12 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_13 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_14 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_15 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkinv_1 I ZN VDD VNW VPW VSS
X_i_0 ZN I VSS VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_1 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkinv_2 I ZN VDD VNW VPW VSS
X_i_0_0 ZN I VSS VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_0_1 VSS I ZN VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_1_0 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrnq_1 D RN CLK Q VDD VNW VPW VSS
X_tn10 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn13 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn11 net10 D VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn15 net10 ncki net1 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn14 net1 cki net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn8 net12 net2 net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn9 VSS RN net12 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn18 VSS net1 net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn0 net8 cki net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn1 net11 ncki net8 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn12 net11 net4 VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn5 net0 RN VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn4 net4 net8 net0 VPW nfet_05v0 W=4e-07 L=6e-07
X_tn3 Q net4 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp8 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp11 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp9 VDD D net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp15 net1 cki net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp7 net9 ncki net1 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp6 VDD net2 net9 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp12 net9 RN VDD VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp18 VDD net1 net2 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp2 net2 ncki net8 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp3 net8 cki net11 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp10 net11 net4 VDD VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp5 net4 RN VDD VNW pfet_05v0 W=1e-06 L=5e-07
X_tp4 VDD net8 net4 VNW pfet_05v0 W=1e-06 L=5e-07
X_tp1 Q net4 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrnq_2 D RN CLK Q VDD VNW VPW VSS
X_tn10 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn13 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn11 net10 D VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn15 net10 ncki net1 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn14 net1 cki net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn8 net12 net2 net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn9 VSS RN net12 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn18 VSS net1 net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn0 net8 cki net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn1 net11 ncki net8 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn12 net11 net4 VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn5 net0 RN VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn4 net4 net8 net0 VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tn3_15 Q net4 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tn3 Q net4 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp8 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp11 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp9 VDD D net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp15 net1 cki net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp7 net9 ncki net1 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp6 VDD net2 net9 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp12 net9 RN VDD VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp18 VDD net1 net2 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp2 net2 ncki net8 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp3 net8 cki net11 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp10 net11 net4 VDD VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp5 net4 RN VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp4 VDD net8 net4 VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp1_13 Q net4 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp1 Q net4 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrsnq_1 D RN SETN CLK Q VDD VNW VPW VSS
X_tn1 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn2 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn0 net14 D VSS VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn8 net14 ncki net3 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn5 net3 cki net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn6 net15 net4 net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn7 VSS RN net15 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn4 net0 net3 VSS VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn3 net4 SETN net0 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn14 net5 cki net4 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn13 net7 ncki net5 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn15 net1 SETN net7 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn16 VSS net6 net1 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn18 net2 RN VSS VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn17 net6 net5 net2 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn19 Q net6 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp1 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp2 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp0 VDD D net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp10 net3 cki net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp7 net13 ncki net3 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp5 VDD net4 net13 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp6 net13 RN VDD VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp4 VDD net3 net4 VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp3 VDD SETN net4 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp20 net4 ncki net5 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp19 net5 cki net7 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp13 net7 SETN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp14 net7 net6 VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp16 net6 RN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp15 VDD net5 net6 VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp17 Q net6 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrsnq_2 D RN SETN CLK Q VDD VNW VPW VSS
X_tn1 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn2 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn0 net14 D VSS VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn8 net14 ncki net3 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn5 net3 cki net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn6 net15 net4 net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn7 VSS RN net15 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn4 net0 net3 VSS VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn3 net4 SETN net0 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn14 net5 cki net4 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn13 net7 ncki net5 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn15 net1 SETN net7 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn16 VSS net6 net1 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn18 net2 RN VSS VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn17 net6 net5 net2 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn19_39 Q net6 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tn19 Q net6 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp1 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp2 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp0 VDD D net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp10 net3 cki net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp7 net13 ncki net3 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp5 VDD net4 net13 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp6 net13 RN VDD VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp4 VDD net3 net4 VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp3 VDD SETN net4 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp20 net4 ncki net5 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp19 net5 cki net7 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp13 net7 SETN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp14 net7 net6 VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp16 net6 RN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp15 VDD net5 net6 VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp17_33 Q net6 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp17 Q net6 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__endcap VDD VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fill_1 VDD VNW VPW VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fill_2 VDD VNW VPW VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fillcap_4 VDD VNW VPW VSS
X_i_17 net_1 net_0 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_19 VDD net_1 net_0 VNW pfet_05v0 W=1.22e-06 L=1e-06
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fillcap_8 VDD VNW VPW VSS
X_i_17 net_3 net_2 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23 net_4 net_5 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_19 VDD net_3 net_2 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7 VDD net_4 net_5 VNW pfet_05v0 W=1.22e-06 L=1e-06
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fillcap_16 VDD VNW VPW VSS
X_i_17 net_3 net_2 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23 net_4 net_5 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_24 net_7 net_9 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_55 net_6 net_8 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_19 VDD net_3 net_2 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7 VDD net_4 net_5 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_33 VDD net_7 net_9 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_23 VDD net_6 net_8 VNW pfet_05v0 W=1.22e-06 L=1e-06
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fillcap_32 VDD VNW VPW VSS
X_i_17 net_3 net_2 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23 net_4 net_5 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_24 net_7 net_9 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_55 net_6 net_8 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_27 net_17 net_14 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_63 net_16 net_15 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_24_22 net_13 net_11 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_55_93 net_12 net_10 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_19 VDD net_3 net_2 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7 VDD net_4 net_5 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_33 VDD net_7 net_9 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_23 VDD net_6 net_8 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_94 VDD net_17 net_14 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_87 VDD net_16 net_15 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_33_95 VDD net_13 net_11 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_23_23 VDD net_12 net_10 VNW pfet_05v0 W=1.22e-06 L=1e-06
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fillcap_64 VDD VNW VPW VSS
X_i_17 net_3 net_2 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23 net_4 net_5 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_24 net_7 net_9 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_55 net_6 net_8 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_27 net_17 net_14 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_63 net_16 net_15 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_24_22 net_13 net_11 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_55_93 net_12 net_10 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_20 net_30 net_26 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_59 net_25 net_20 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_24_135 net_23 net_28 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_55_90 net_33 net_18 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_27_139 net_31 net_29 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_63_82 net_32 net_24 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_24_22_30 net_22 net_27 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23_55_93_110 net_19 net_21 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_19 VDD net_3 net_2 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7 VDD net_4 net_5 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_33 VDD net_7 net_9 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_23 VDD net_6 net_8 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_94 VDD net_17 net_14 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_87 VDD net_16 net_15 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_33_95 VDD net_13 net_11 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_23_23 VDD net_12 net_10 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_95 VDD net_30 net_26 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_188 VDD net_25 net_20 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_33_98 VDD net_23 net_28 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_23_16 VDD net_33 net_18 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_94_91 VDD net_31 net_29 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_87_65 VDD net_32 net_24 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_33_95_109 VDD net_22 net_27 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7_23_23_99 VDD net_19 net_21 VNW pfet_05v0 W=1.22e-06 L=1e-06
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__filltie VDD VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__inv_2 I ZN VDD VNW VPW VSS
X_i_0_0 ZN I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS I ZN VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_1_0 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__inv_4 I ZN VDD VNW VPW VSS
X_i_0_0 ZN I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS I ZN VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_2 ZN I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_3 VSS I ZN VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_1_0 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__mux2_2 I0 I1 S Z VDD VNW VPW VSS
X_MN2_12 VSS int04 Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN2 VSS int04 Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN4 net_1 I1 VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN8 int04 S net_1 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN7 net_3 sel1_n int04 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN3 VSS I0 net_3 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN1 sel1_n S VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MP5_6 VDD int04 Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP5 VDD int04 Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP4 net_0 I1 VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP8 int04 sel1_n net_0 VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP7 net_2 S int04 VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP3 VDD I0 net_2 VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP1 sel1_n S VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__nand2_1 A1 A2 ZN VDD VNW VPW VSS
X_i_1 net_0 A2 VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0 ZN A1 net_0 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3 ZN A2 VDD VNW pfet_05v0 W=1.13e-06 L=5e-07
X_i_2 VDD A1 ZN VNW pfet_05v0 W=1.13e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__nor2_1 A1 A2 ZN VDD VNW VPW VSS
X_i_1 ZN A2 VSS VPW nfet_05v0 W=5.65e-07 L=6e-07
X_i_0 VSS A1 ZN VPW nfet_05v0 W=5.65e-07 L=6e-07
X_i_3 net_0 A2 VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_2 ZN A1 net_0 VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__or2_1 A1 A2 Z VDD VNW VPW VSS
X_i_2 Z_neg A1 VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_3 VSS A2 Z_neg VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_4 net_0 A1 Z_neg VNW pfet_05v0 W=5.65e-07 L=5e-07
X_i_5 VDD A2 net_0 VNW pfet_05v0 W=5.65e-07 L=5e-07
X_i_1 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__tieh Z VDD VNW VPW VSS
X_n_tran_1 VSS A A VPW nfet_05v0 W=0.82U L=0.600000U
X_p_tran_2 VDD A Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS


* --- DISEÑO DIGITAL ---
X1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X2 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X3 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X4 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X5 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X6 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X7 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X8 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X9 _131_/D _131_/RN _119_/Z _142_/CLK _131_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_1
X10 _157_/I _062_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_2
X11 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X12 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X13 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X14 _110_/I _142_/D _114_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X15 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X16 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X17 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X18 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X19 _152_/Z SW0n[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X20 _163_/Z SW1n[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X21 output42/I SW1p[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X22 _062_/ZN B[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X23 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X24 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X25 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X26 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X27 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X28 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X29 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X30 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X31 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X32 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X33 _130_/D _130_/RN _118_/Z _143_/CLK _130_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X34 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X35 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X36 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X37 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X38 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X39 _061_/I _061_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X40 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X41 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X42 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X43 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X44 _110_/I _142_/D _113_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X45 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X46 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X47 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X48 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X49 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X50 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X51 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X52 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X53 _065_/ZN B[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X54 _153_/Z SW0n[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X55 _164_/Z SW1n[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X56 output43/I SW1p[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X57 _063_/ZN B[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X58 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X59 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X60 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X61 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X62 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X63 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X64 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X65 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X66 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X67 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X68 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X69 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X70 _146_/I _060_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_2
X71 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X72 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X73 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X74 _110_/I _118_/A2 _112_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X75 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X76 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X77 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X78 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X79 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X80 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X81 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X82 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X83 _066_/ZN B[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X84 _154_/Z SW0p[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X85 _165_/Z SW1n[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X86 output44/I SW1p[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X87 _064_/ZN B[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X88 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X89 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X90 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X91 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X92 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X93 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X94 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X95 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X96 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X97 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X98 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X99 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X100 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X101 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X102 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X103 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X104 _122_/I _143_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X105 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X106 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X107 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X108 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X109 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X110 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X111 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X112 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X113 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X114 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X115 _067_/ZN B[9] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X116 output23/I SW0p[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X117 _166_/Z SW1n[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X118 output45/I SW1p[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X119 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X120 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X121 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X122 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X123 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X124 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X125 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X126 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X127 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X128 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X129 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X130 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X131 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X132 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X133 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X134 _143_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__TIEH
X135 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X136 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X137 _143_/CLK clkload0/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_4
X138 _110_/I _142_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X139 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X140 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X141 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X142 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X143 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X144 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X145 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X146 _145_/Z SW0n[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X147 _156_/Z SW0p[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X148 _167_/Z SW1n[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X149 output46/I SW1p[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X150 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X151 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X152 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X153 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X154 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X155 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X156 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X157 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X158 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X159 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X160 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X161 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X162 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X163 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X164 clkbuf_0_CLK/Z _143_/CLK VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_16
X165 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X166 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X167 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X168 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X169 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X170 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X171 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X172 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X173 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X174 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X175 _169_/I _169_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X176 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X177 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X178 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X179 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X180 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X181 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X182 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X183 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X184 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X185 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X186 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X187 _146_/Z SW0n[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X188 _157_/Z SW0p[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X189 _168_/Z SW1n[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X190 output47/I SW1p[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X191 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X192 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X193 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X194 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X195 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X196 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X197 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X198 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X199 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X200 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X201 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X202 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X203 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X204 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X205 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X206 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X207 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X208 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X209 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X210 _168_/I _168_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X211 _110_/I _126_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X212 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X213 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X214 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X215 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X216 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X217 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X218 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X219 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X220 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X221 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X222 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X223 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X224 _147_/Z SW0n[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X225 _158_/Z SW0p[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X226 _169_/Z SW1n[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X227 output48/I SW1p[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X228 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X229 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X230 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X231 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X232 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X233 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X234 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X235 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X236 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X237 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X238 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X239 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X240 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X241 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X242 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X243 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X244 _167_/I _167_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X245 _121_/I _127_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X246 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X247 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X248 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X249 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X250 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X251 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X252 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X253 _148_/Z SW0n[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X254 _159_/Z SW0p[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X255 _170_/Z SW1n[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X256 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X257 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X258 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X259 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X260 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X261 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X262 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X263 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X264 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X265 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X266 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X267 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X268 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X269 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X270 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X271 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X272 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X273 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X274 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X275 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X276 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X277 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X278 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X279 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X280 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X281 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X282 _166_/I _166_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X283 _097_/I _128_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X284 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X285 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X286 _158_/I _149_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X287 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X288 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X289 _149_/Z SW0n[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X290 _160_/Z SW0p[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X291 output39/I SW1n[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X292 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X293 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X294 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X295 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X296 _125_/Q _088_/I1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X297 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X298 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X299 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X300 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X301 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X302 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X303 hold105/Z hold106/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X304 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X305 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X306 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X307 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X308 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X309 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X310 _165_/I _165_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X311 _097_/I _129_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X312 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X313 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X314 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X315 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X316 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X317 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X318 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X319 _157_/I _148_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X320 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X321 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X322 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X323 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X324 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X325 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X326 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X327 _150_/Z SW0n[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X328 _161_/Z SW0p[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X329 _079_/A1 _081_/A1 _080_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X330 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X331 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X332 _167_/I output44/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X333 _124_/Q _161_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X334 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X335 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X336 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X337 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X338 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X339 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X340 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X341 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X342 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X343 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X344 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X345 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X346 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X347 input1/Z _097_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X348 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X349 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X350 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X351 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X352 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X353 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X354 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X355 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X356 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X357 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X358 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X359 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X360 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X361 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X362 _164_/I _164_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X363 _097_/I _095_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X364 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X365 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X366 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X367 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X368 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X369 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X370 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X371 _156_/I _147_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X372 _078_/I0 _092_/I0 _078_/S _130_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X373 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X374 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X375 _088_/I1 SW0n[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X376 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X377 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X378 _166_/I output43/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X379 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X380 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X381 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X382 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X383 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X384 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X385 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X386 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X387 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X388 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X389 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X390 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X391 _095_/ZN _130_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X392 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X393 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X394 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X395 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X396 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X397 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X398 _163_/I _163_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X399 _122_/I _131_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X400 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X401 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X402 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X403 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X404 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X405 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X406 _146_/I _146_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X407 _077_/A1 _079_/A1 wire52/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X408 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X409 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X410 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X411 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X412 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X413 _165_/I output42/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X414 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X415 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X416 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X417 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X418 _129_/D _129_/RN _117_/Z _143_/CLK _129_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X419 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X420 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X421 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X422 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X423 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X424 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X425 SAMP hold105/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X426 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X427 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X428 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X429 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X430 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X431 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X432 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X433 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X434 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X435 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X436 _162_/I _162_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X437 _110_/I _118_/A2 _093_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X438 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X439 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X440 input1/I input1/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X441 _154_/I _145_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X442 wire75/Z _154_/I _076_/S _131_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X443 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X444 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X445 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X446 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X447 _164_/I output41/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X448 wire75/Z _092_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X449 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X450 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X451 _128_/D _128_/RN _116_/Z _143_/CLK _157_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X452 _059_/I _059_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X453 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X454 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X455 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X456 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X457 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X458 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X459 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X460 hold106/I input1/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X461 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X462 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X463 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X464 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X465 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X466 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X467 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X468 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X469 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X470 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X471 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X472 _161_/I _161_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X473 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X474 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X475 _092_/I0 _162_/I _092_/S _123_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X476 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X477 Vcomp wire75/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X478 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X479 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X480 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X481 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X482 _075_/A1 _077_/A1 _076_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X483 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X484 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X485 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X486 _163_/I output40/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X487 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X488 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X489 _127_/D _127_/RN _115_/Z _142_/CLK _127_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_1
X490 _132_/Q _058_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X491 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X492 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X493 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X494 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X495 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X496 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X497 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X498 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X499 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X500 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X501 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X502 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X503 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X504 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X505 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X506 _160_/I _160_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X507 _091_/A1 _118_/A2 _092_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X508 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X509 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X510 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X511 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X512 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X513 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X514 _143_/D _143_/RN _143_/CLK _143_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_1
X515 _132_/Q wire73/Z _074_/S _132_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X516 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X517 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X518 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X519 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X520 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X521 _143_/Q _142_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X522 _131_/Q _154_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X523 _126_/D _126_/RN _114_/Z _143_/CLK _159_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X524 _121_/I _132_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X525 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X526 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X527 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X528 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X529 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X530 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X531 _121_/I _141_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X532 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X533 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X534 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X535 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X536 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X537 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X538 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X539 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X540 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X541 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X542 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X543 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X544 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X545 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X546 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X547 _066_/I _092_/I0 _090_/S _124_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X548 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X549 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X550 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X551 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X552 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X553 _142_/D _142_/RN _142_/CLK _142_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X554 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X555 _075_/A1 _133_/Q wire53/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X556 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X557 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X558 _143_/Q _118_/A2 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X559 _130_/Q _146_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X560 _097_/I _122_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X561 _125_/D _125_/RN _113_/Z _143_/CLK _125_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X562 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X563 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X564 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X565 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X566 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X567 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X568 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X569 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X570 _121_/I _140_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X571 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X572 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X573 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X574 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X575 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X576 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X577 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X578 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X579 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X580 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X581 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X582 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X583 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X584 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X585 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X586 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X587 _141_/D _141_/RN _142_/CLK _170_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X588 _072_/I _091_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X589 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X590 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X591 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X592 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X593 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X594 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X595 max_cap56/I output48/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X596 _129_/Q _156_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X597 _097_/I _110_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X598 _124_/D _124_/RN _112_/Z _143_/CLK _124_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_1
X599 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X600 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X601 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X602 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X603 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X604 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X605 _121_/I _139_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X606 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X607 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X608 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X609 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X610 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X611 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X612 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X613 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X614 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X615 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X616 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X617 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X618 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X619 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X620 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X621 _170_/I _140_/RN _142_/CLK _169_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X622 _139_/D _087_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X623 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X624 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X625 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X626 _170_/I output47/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X627 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X628 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X629 _123_/D _123_/RN _093_/Z _143_/CLK _123_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_1
X630 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X631 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X632 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X633 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X634 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X635 _121_/I _138_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X636 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X637 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X638 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X639 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X640 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X641 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X642 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X643 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X644 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X645 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X646 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X647 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X648 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X649 _137_/D _083_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X650 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X651 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X652 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X653 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X654 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X655 _169_/I output46/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X656 _127_/Q _158_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X657 _122_/I _134_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X658 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X659 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X660 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X661 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X662 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X663 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X664 _121_/I _137_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X665 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X666 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X667 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X668 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X669 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X670 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X671 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X672 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X673 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X674 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X675 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X676 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X677 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X678 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X679 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X680 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X681 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X682 _168_/I output45/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X683 _121_/I _133_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X684 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X685 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X686 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X687 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X688 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X689 _122_/I _136_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X690 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X691 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X692 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X693 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X694 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X695 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X696 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X697 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X698 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X699 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X700 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X701 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X702 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X703 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X704 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X705 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X706 _121_/I _142_/D _120_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X707 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X708 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X709 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X710 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X711 _122_/I _135_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X712 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X713 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X714 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X715 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X716 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X717 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X718 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X719 Vcomp VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__ANTENNA
X720 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X721 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X722 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X723 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X724 output41/I _077_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X725 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X726 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X727 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X728 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X729 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X730 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X731 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X732 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X733 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X734 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X735 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X736 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X737 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X738 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X739 _110_/I _123_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X740 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X741 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X742 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X743 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X744 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X745 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X746 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X747 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X748 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X749 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X750 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X751 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X752 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X753 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X754 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X755 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X756 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X757 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X758 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X759 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X760 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X761 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X762 _131_/Q _059_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X763 output48/I _072_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X764 CLK clkbuf_0_CLK/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_16
X765 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X766 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X767 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X768 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X769 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X770 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X771 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X772 _110_/I _124_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X773 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X774 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X775 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X776 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X777 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X778 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X779 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X780 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X781 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X782 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X783 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X784 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X785 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X786 _129_/Q _061_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X787 rebuffer93/Z _135_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X788 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X789 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X790 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X791 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X792 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X793 wire50/I _086_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X794 _123_/Q _162_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X795 _110_/I _125_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X796 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X797 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X798 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X799 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X800 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X801 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X802 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X803 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X804 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X805 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X806 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X807 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X808 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X809 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X810 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X811 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X812 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X813 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X814 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X815 _125_/Q _160_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X816 output42/I rebuffer93/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X817 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X818 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X819 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X820 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X821 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X822 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X823 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X824 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X825 wire51/I _082_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X826 wire75/Z wire73/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X827 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X828 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X829 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X830 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X831 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X832 _159_/I _159_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X833 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X834 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X835 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X836 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X837 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X838 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X839 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X840 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X841 _130_/Q output23/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X842 output40/I _133_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X843 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X844 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X845 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X846 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X847 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X848 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X849 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X850 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X851 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X852 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X853 CLK VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__ANTENNA
X854 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X855 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X856 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X857 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X858 wire52/I _078_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X859 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X860 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X861 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X862 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X863 _158_/I _158_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X864 _089_/A1 _091_/A1 wire49/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X865 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X866 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X867 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X868 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X869 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X870 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X871 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X872 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X873 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X874 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X875 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X876 _124_/Q _066_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X877 output45/I _085_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X878 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X879 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X880 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X881 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X882 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X883 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X884 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X885 wire53/I _074_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X886 wire75/I wire75/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X887 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X888 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X889 _157_/I _157_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X890 wire73/Z _088_/I1 _088_/S _125_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X891 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X892 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X893 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X894 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X895 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X896 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X897 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X898 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X899 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X900 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X901 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X902 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X903 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X904 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X905 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X906 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X907 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X908 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X909 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X910 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X911 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X912 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X913 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X914 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X915 _123_/Q _067_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X916 output46/I _139_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X917 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X918 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X919 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X920 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X921 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X922 _097_/I _121_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X923 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X924 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X925 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X926 _156_/I _156_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X927 _087_/A1 _089_/A1 _088_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X928 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X929 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X930 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X931 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X932 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X933 _139_/D _139_/RN _142_/CLK _168_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X934 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X935 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X936 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X937 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X938 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X939 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X940 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X941 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X942 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X943 _127_/Q _063_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X944 output44/I _137_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X945 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X946 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X947 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X948 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X949 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X950 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X951 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X952 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X953 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X954 _159_/I wire73/Z _086_/S _126_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X955 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X956 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X957 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X958 _168_/I _138_/RN _142_/CLK _167_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X959 _135_/D _079_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X960 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X961 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X962 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X963 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X964 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X965 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X966 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X967 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X968 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X969 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X970 _142_/Q max_cap56/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X971 output23/I _078_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X972 output47/I _089_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X973 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X974 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X975 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X976 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X977 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X978 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X979 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X980 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X981 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X982 _154_/I _154_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X983 _085_/A1 _087_/A1 wire50/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X984 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X985 _137_/D _137_/RN _142_/CLK _166_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X986 _133_/D _075_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X987 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X988 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X989 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X990 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X991 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X992 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X993 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X994 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X995 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X996 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X997 output39/I _141_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X998 _142_/Q output39/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X999 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1000 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1001 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1002 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1003 _170_/I _170_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1004 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1005 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1006 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1007 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1008 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X1009 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1010 _162_/I _153_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X1011 wire73/Z _158_/I _084_/S _127_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X1012 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X1013 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1014 _166_/I _136_/RN _142_/CLK _165_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X1015 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1016 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1017 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1018 _067_/I _067_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X1019 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1020 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1021 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1022 _122_/I _143_/Q _119_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X1023 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1024 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1025 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1026 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1027 output43/I _081_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1028 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X1029 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1030 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1031 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1032 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1033 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1034 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1035 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1036 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1037 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1038 _161_/I _152_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X1039 _083_/A1 _085_/A1 _084_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X1040 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1041 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1042 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1043 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1044 _135_/D _135_/RN _142_/CLK _164_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X1045 _066_/I _066_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X1046 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1047 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1048 _122_/I _118_/A2 _118_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X1049 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1050 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1051 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1052 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1053 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1054 _058_/ZN B[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1055 SAMP VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__ANTENNA
X1056 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1057 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1058 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X1059 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1060 _157_/I wire75/Z _082_/S _128_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X1061 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1062 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1063 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1064 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1065 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1066 _164_/I _134_/RN _142_/CLK _163_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X1067 _160_/I _065_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_2
X1068 _097_/I _118_/A2 _117_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X1069 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1070 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1071 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1072 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1073 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1074 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1075 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_16
X1076 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1077 _059_/ZN B[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1078 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1079 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1080 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1081 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1082 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1083 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1084 wire49/I _090_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X1085 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1086 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1087 _159_/I _150_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X1088 _081_/A1 _083_/A1 wire51/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X1089 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1090 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1091 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1092 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1093 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1094 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1095 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1096 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1097 _133_/D _133_/RN _142_/CLK _133_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_1
X1098 _159_/I _064_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_2
X1099 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1100 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1101 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1102 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1103 _097_/I _143_/Q _116_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X1104 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X1105 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1106 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_64
X1107 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1108 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_32
X1109 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1110 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1111 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1112 output40/I SW1p[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1113 _060_/ZN B[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1114 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1115 clkbuf_0_CLK/Z _142_/CLK VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_16
X1116 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1117 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1118 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1119 _092_/I0 _061_/I _080_/S _129_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X1120 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X1121 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1122 _132_/D _132_/RN _120_/Z _142_/CLK _132_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_1
X1123 _063_/I _063_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X1124 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1125 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1126 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X1127 _121_/I _142_/D _115_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X1128 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1129 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X1130 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X1131 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X1132 _162_/Z SW0p[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1133 output41/I SW1p[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1134 _061_/ZN B[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X1135 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4


**** end user architecture code
.ends

.end
