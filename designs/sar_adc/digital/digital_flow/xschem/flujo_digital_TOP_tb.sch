** sch_path: designs/sar_adc/digital/digital_flow/xschem/flujo_digital_TOP_tb.sch
**.subckt flujo_digital_TOP_tb
V2 VDD 0 {VDD}
V3 VSS 0 0
VCOMP Vcomp 0 PULSE(0 {VDD} {3.4*Tclk} 0.1n 0.1n {Ts/2} {Ts})
VCLK CLK 0 PULSE({VDD} 0 0 0.1n 0.1n {Tclk/2} {Tclk})
VSAM SAMP 0 PULSE(0 {VDD} 0 0.1n 0.1n {Tclk} {Ts})
xREG VDD CLK SAMP Vcomp net1[8] net1[7] net1[6] net1[5] net1[4] net1[3] net1[2] net1[1] net1[0] B[9]
+ B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] SW1[8] SW1[7] SW1[6] SW1[5] SW1[4] SW1[3] SW1[2] SW1[1]
+ SW1[0] VSS SW0[8] SW0[7] SW0[6] SW0[5] SW0[4] SW0[3] SW0[2] SW0[1] SW0[0] net2[8] net2[7] net2[6] net2[5]
+ net2[4] net2[3] net2[2] net2[1] net2[0] eoc sar_logic
**** begin user architecture code

.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical



* Input parameters
.param VDD = 3.3
.param Fs = 5Meg
.param Ts = 1/Fs
.param Tclk = 1/(Fs*12)

.control
save all

* Variables
let Fs = 5Meg
let tstep = 1/(Fs*12*100)
let tstop = 1/Fs+50n


* Transient simulation
tran $&tstep $&tstop

let i_vdd = -i(V2)
let p_inst = -v(VDD)*i(V2)
** Plots
meas tran Iavg AVG i_vdd FROM=$&tstep TO=$&tstop
meas tran Pavg AVG p_inst FROM=$&tstep TO=$&tstop

*plot xREG.SAMPN xREG.SET

plot "sw0[0]" "sw0[1]"+4 "sw0[2]"+8 "sw0[3]"+12 "sw0[4]"+16 "sw0[5]"+20 "sw0[6]"+24 "sw0[7]"+28
+ "sw0[8]"+32 Vcomp+36 SAMP+40 CLK+44
plot "sw1[0]" "sw1[1]"+4 "sw1[2]"+8 "sw1[3]"+12 "sw1[4]"+16 "sw1[5]"+20 "sw1[6]"+24 "sw1[7]"+28
+ "sw1[8]"+32 Vcomp+36 SAMP+40 CLK+44
plot "B[0]" "B[1]"+4 "B[2]"+8 "B[3]"+12 "B[4]"+16 "B[5]"+20 "B[6]"+24 "B[7]"+28 "B[8]"+32 "B[9]"+36
+ Vcomp+40 SAMP+44 CLK+48
.endc


**** end user architecture code
**.ends

* expanding   symbol:  designs/sar_adc/digital/digital_flow/xschem/sar_logic.sym # of pins=11
** sym_path: designs/sar_adc/digital/digital_flow/xschem/sar_logic.sym
** sch_path: designs/sar_adc/digital/digital_flow/xschem/sar_logic.sch
.subckt sar_logic VDD CLK SAMP Vcomp SW0n[8] SW0n[7] SW0n[6] SW0n[5] SW0n[4] SW0n[3] SW0n[2] SW0n[1]
+ SW0n[0] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] SW1p[8] SW1p[7] SW1p[6] SW1p[5] SW1p[4] SW1p[3]
+ SW1p[2] SW1p[1] SW1p[0] VSS SW0p[8] SW0p[7] SW0p[6] SW0p[5] SW0p[4] SW0p[3] SW0p[2] SW0p[1] SW0p[0] SW1n[8]
+ SW1n[7] SW1n[6] SW1n[5] SW1n[4] SW1n[3] SW1n[2] SW1n[1] SW1n[0] eoc
*.iopin VDD
*.iopin VSS
*.iopin SAMP
*.iopin CLK
*.iopin B[9],B[8],B[7],B[6],B[5],B[4],B[3],B[2],B[1],B[0]
*.iopin SW0n[8],SW0n[7],SW0n[6],SW0n[5],SW0n[4],SW0n[3],SW0n[2],SW0n[1],SW0n[0]
*.iopin SW1n[8],SW1n[7],SW1n[6],SW1n[5],SW1n[4],SW1n[3],SW1n[2],SW1n[1],SW1n[0]
*.iopin Vcomp
*.iopin SW0p[8],SW0p[7],SW0p[6],SW0p[5],SW0p[4],SW0p[3],SW0p[2],SW0p[1],SW0p[0]
*.iopin SW1p[8],SW1p[7],SW1p[6],SW1p[5],SW1p[4],SW1p[3],SW1p[2],SW1p[1],SW1p[0]
*.iopin eoc
**** begin user architecture code

* ==========================================
* LVS READY - MÓDULO: SAR_LOGIC
* ==========================================

.SUBCKT gf180mcu_fd_sc_mcu7t5v0__antenna I VDD VNW VPW VSS
*D0 VPW I diode_nd2ps_06v0 AREA=0.2052p PJ=1.86u M=1
*D1 I VNW diode_pd2nw_06v0 AREA=0.2052p PJ=1.86u M=1
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_1 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=5.65e-07 L=5e-07
X_i_1 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_2 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_3 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_2 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_4 I Z VDD VNW VPW VSS
X_i_2_0 Z_neg I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_2_1 VSS I Z_neg VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_2 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_3 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3_0 Z_neg I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_3_1 VDD I Z_neg VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__buf_8 I Z VDD VNW VPW VSS
X_i_2_0 Z_neg I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_2_1 VSS I Z_neg VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_2_2 Z_neg I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_2_3 VSS I Z_neg VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_2 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_3 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_4 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_5 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_6 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_7 VSS Z_neg Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3_0 Z_neg I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_3_1 VDD I Z_neg VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_3_2 Z_neg I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_3_3 VDD I Z_neg VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_4 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_5 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_6 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_7 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkbuf_1 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_0 Z Z_neg VSS VPW nfet_05v0 W=4.95e-07 L=6e-07
* The device in the netlist is split in half, suggesting a two-fingered
* FET, which this is not.  Modified by Tim E. Nov. 3, 2025 to properly
* match the layout.
* M_i_3 VDD I Z_neg VNW pfet_05v0 W=5.25e-07 L=5e-07
* M_i_3_0 VDD I Z_neg VNW pfet_05v0 W=5.25e-07 L=5e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=1.05e-06 L=5e-07
X_i_1 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkbuf_2 I Z VDD VNW VPW VSS
X_i_2 VSS I Z_neg VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_3 VDD I Z_neg VNW pfet_05v0 W=1.02e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkbuf_4 I Z VDD VNW VPW VSS
X_i_2_1 VSS I Z_neg VPW nfet_05v0 W=6.05e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=4.55e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=4.55e-07 L=6e-07
X_i_0_2 Z Z_neg VSS VPW nfet_05v0 W=4.55e-07 L=6e-07
X_i_0_3 VSS Z_neg Z VPW nfet_05v0 W=4.55e-07 L=6e-07
X_i_3_0 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_1 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkbuf_16 I Z VDD VNW VPW VSS
X_i_2_0 Z_neg I VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_1 VSS I Z_neg VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_2 Z_neg I VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_3 VSS I Z_neg VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_4 Z_neg I VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_2_5 VSS I Z_neg VPW nfet_05v0 W=4.05e-07 L=6e-07
X_i_0_0 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_1 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_2 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_3 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_4 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_5 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_6 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_7 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_8 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_9 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_10 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_11 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_12 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_13 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_14 Z Z_neg VSS VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_0_15 VSS Z_neg Z VPW nfet_05v0 W=4.85e-07 L=6e-07
X_i_3_0 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_1 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_2 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_3 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_4 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_5 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_6 Z_neg I VDD VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_3_7 VDD I Z_neg VNW pfet_05v0 W=0.82e-06 L=5e-07
X_i_1_0 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_4 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_5 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_6 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_7 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_8 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_9 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_10 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_11 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_12 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_13 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_14 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_15 VDD Z_neg Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkinv_1 I ZN VDD VNW VPW VSS
X_i_0 ZN I VSS VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_1 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkinv_3 I ZN VDD VNW VPW VSS
X_i_0_0 ZN I VSS VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_0_1 VSS I ZN VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_0_2 ZN I VSS VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_1_0 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__clkinv_4 I ZN VDD VNW VPW VSS
X_i_0_0 ZN I VSS VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_0_1 VSS I ZN VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_0_2 ZN I VSS VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_0_3 VSS I ZN VPW nfet_05v0 W=4.8e-07 L=6e-07
X_i_1_0 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrnq_1 D RN CLK Q VDD VNW VPW VSS
X_tn10 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn13 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn11 net10 D VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn15 net10 ncki net1 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn14 net1 cki net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn8 net12 net2 net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn9 VSS RN net12 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn18 VSS net1 net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn0 net8 cki net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn1 net11 ncki net8 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn12 net11 net4 VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn5 net0 RN VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn4 net4 net8 net0 VPW nfet_05v0 W=4e-07 L=6e-07
X_tn3 Q net4 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp8 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp11 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp9 VDD D net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp15 net1 cki net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp7 net9 ncki net1 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp6 VDD net2 net9 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp12 net9 RN VDD VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp18 VDD net1 net2 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp2 net2 ncki net8 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp3 net8 cki net11 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp10 net11 net4 VDD VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp5 net4 RN VDD VNW pfet_05v0 W=1e-06 L=5e-07
X_tp4 VDD net8 net4 VNW pfet_05v0 W=1e-06 L=5e-07
X_tp1 Q net4 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrnq_2 D RN CLK Q VDD VNW VPW VSS
X_tn10 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn13 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn11 net10 D VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn15 net10 ncki net1 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn14 net1 cki net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn8 net12 net2 net15 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn9 VSS RN net12 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn18 VSS net1 net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn0 net8 cki net2 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn1 net11 ncki net8 VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn12 net11 net4 VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn5 net0 RN VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_tn4 net4 net8 net0 VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tn3_15 Q net4 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tn3 Q net4 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp8 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp11 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp9 VDD D net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp15 net1 cki net10 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp7 net9 ncki net1 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp6 VDD net2 net9 VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp12 net9 RN VDD VNW pfet_05v0 W=7.8e-07 L=5e-07
X_tp18 VDD net1 net2 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp2 net2 ncki net8 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp3 net8 cki net11 VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp10 net11 net4 VDD VNW pfet_05v0 W=5.05e-07 L=5e-07
X_tp5 net4 RN VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp4 VDD net8 net4 VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp1_13 Q net4 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp1 Q net4 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrsnq_1 D RN SETN CLK Q VDD VNW VPW VSS
X_tn1 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn2 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn0 net14 D VSS VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn8 net14 ncki net3 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn5 net3 cki net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn6 net15 net4 net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn7 VSS RN net15 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn4 net0 net3 VSS VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn3 net4 SETN net0 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn14 net5 cki net4 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn13 net7 ncki net5 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn15 net1 SETN net7 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn16 VSS net6 net1 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn18 net2 RN VSS VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn17 net6 net5 net2 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn19 Q net6 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp1 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp2 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp0 VDD D net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp10 net3 cki net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp7 net13 ncki net3 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp5 VDD net4 net13 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp6 net13 RN VDD VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp4 VDD net3 net4 VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp3 VDD SETN net4 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp20 net4 ncki net5 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp19 net5 cki net7 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp13 net7 SETN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp14 net7 net6 VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp16 net6 RN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp15 VDD net5 net6 VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp17 Q net6 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__dffrsnq_2 D RN SETN CLK Q VDD VNW VPW VSS
X_tn1 ncki CLK VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn2 cki ncki VSS VPW nfet_05v0 W=4.05e-07 L=6e-07
X_tn0 net14 D VSS VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn8 net14 ncki net3 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn5 net3 cki net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn6 net15 net4 net16 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn7 VSS RN net15 VPW nfet_05v0 W=3.65e-07 L=6e-07
X_tn4 net0 net3 VSS VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn3 net4 SETN net0 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn14 net5 cki net4 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn13 net7 ncki net5 VPW nfet_05v0 W=5.05e-07 L=6e-07
X_tn15 net1 SETN net7 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn16 VSS net6 net1 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn18 net2 RN VSS VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn17 net6 net5 net2 VPW nfet_05v0 W=3.8e-07 L=6e-07
X_tn19_39 Q net6 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tn19 Q net6 VSS VPW nfet_05v0 W=8.15e-07 L=6e-07
X_tp1 ncki CLK VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp2 cki ncki VDD VNW pfet_05v0 W=8.65e-07 L=5e-07
X_tp0 VDD D net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp10 net3 cki net14 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp7 net13 ncki net3 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp5 VDD net4 net13 VNW pfet_05v0 W=3.65e-07 L=5e-07
X_tp6 net13 RN VDD VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp4 VDD net3 net4 VNW pfet_05v0 W=7.55e-07 L=5e-07
X_tp3 VDD SETN net4 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp20 net4 ncki net5 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp19 net5 cki net7 VNW pfet_05v0 W=3.6e-07 L=5e-07
X_tp13 net7 SETN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp14 net7 net6 VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp16 net6 RN VDD VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp15 VDD net5 net6 VNW pfet_05v0 W=7.7e-07 L=5e-07
X_tp17_33 Q net6 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
X_tp17 Q net6 VDD VNW pfet_05v0 W=1.215e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__endcap VDD VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fill_1 VDD VNW VPW VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fill_2 VDD VNW VPW VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fillcap_4 VDD VNW VPW VSS
X_i_17 net_1 net_0 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_19 VDD net_1 net_0 VNW pfet_05v0 W=1.22e-06 L=1e-06
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__fillcap_8 VDD VNW VPW VSS
X_i_17 net_3 net_2 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_17_23 net_4 net_5 VSS VPW nfet_05v0 W=8.2e-07 L=1e-06
X_i_19 VDD net_3 net_2 VNW pfet_05v0 W=1.22e-06 L=1e-06
X_i_19_7 VDD net_4 net_5 VNW pfet_05v0 W=1.22e-06 L=1e-06
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__filltie VDD VSS
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__inv_2 I ZN VDD VNW VPW VSS
X_i_0_0 ZN I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS I ZN VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_1_0 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__inv_4 I ZN VDD VNW VPW VSS
X_i_0_0 ZN I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_1 VSS I ZN VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_2 ZN I VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0_3 VSS I ZN VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_1_0 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_1 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_2 ZN I VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_1_3 VDD I ZN VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__mux2_2 I0 I1 S Z VDD VNW VPW VSS
X_MN2_12 VSS int04 Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN2 VSS int04 Z VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN4 net_1 I1 VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN8 int04 S net_1 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN7 net_3 sel1_n int04 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN3 VSS I0 net_3 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MN1 sel1_n S VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_MP5_6 VDD int04 Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP5 VDD int04 Z VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP4 net_0 I1 VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP8 int04 sel1_n net_0 VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP7 net_2 S int04 VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP3 VDD I0 net_2 VNW pfet_05v0 W=1.22e-06 L=5e-07
X_MP1 sel1_n S VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__nand2_1 A1 A2 ZN VDD VNW VPW VSS
X_i_1 net_0 A2 VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_0 ZN A1 net_0 VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_3 ZN A2 VDD VNW pfet_05v0 W=1.13e-06 L=5e-07
X_i_2 VDD A1 ZN VNW pfet_05v0 W=1.13e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__nor2_1 A1 A2 ZN VDD VNW VPW VSS
X_i_1 ZN A2 VSS VPW nfet_05v0 W=5.65e-07 L=6e-07
X_i_0 VSS A1 ZN VPW nfet_05v0 W=5.65e-07 L=6e-07
X_i_3 net_0 A2 VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
X_i_2 ZN A1 net_0 VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__or2_1 A1 A2 Z VDD VNW VPW VSS
X_i_2 Z_neg A1 VSS VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_3 VSS A2 Z_neg VPW nfet_05v0 W=3.6e-07 L=6e-07
X_i_0 Z Z_neg VSS VPW nfet_05v0 W=8.2e-07 L=6e-07
X_i_4 net_0 A1 Z_neg VNW pfet_05v0 W=5.65e-07 L=5e-07
X_i_5 VDD A2 net_0 VNW pfet_05v0 W=5.65e-07 L=5e-07
X_i_1 Z Z_neg VDD VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS
.SUBCKT gf180mcu_fd_sc_mcu7t5v0__tieh Z VDD VNW VPW VSS
X_n_tran_1 VSS A A VPW nfet_05v0 W=0.82U L=0.600000U
X_p_tran_2 VDD A Z VNW pfet_05v0 W=1.22e-06 L=5e-07
.ENDS


* --- DISEÑO DIGITAL ---
*.subckt sar_logic B[0] B[1] B[2] B[3] B[4] B[5] B[6] B[7] B[8] B[9] CLK SAMP SW0n[0]
*+ SW0n[1] SW0n[2] SW0n[3] SW0n[4] SW0n[5] SW0n[6] SW0n[7] SW0n[8] SW0p[0] SW0p[1]
*+ SW0p[2] SW0p[3] SW0p[4] SW0p[5] SW0p[6] SW0p[7] SW0p[8] SW1n[0] SW1n[1] SW1n[2]
*+ SW1n[3] SW1n[4] SW1n[5] SW1n[6] SW1n[7] SW1n[8] SW1p[0] SW1p[1] SW1p[2] SW1p[3]
*+ SW1p[4] SW1p[5] SW1p[6] SW1p[7] SW1p[8] VDD VSS Vcomp eoc
X1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X2 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X3 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X4 _131_/D _131_/RN _119_/Z _142_/CLK _131_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X5 _062_/I _062_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_4
X6 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X7 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X8 _121_/I _114_/A2 _114_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X9 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X10 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X11 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X12 rebuffer108/Z rebuffer107/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X13 output46/I _071_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X14 _152_/Z SW0n[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X15 _163_/Z SW1n[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X16 output42/I SW1p[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X17 _062_/ZN B[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X18 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X19 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X20 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X21 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X22 _130_/D _130_/RN _118_/Z _142_/CLK _155_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X23 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X24 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X25 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X26 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X27 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X28 _147_/I _061_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_2
X29 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X30 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X31 _122_/I _142_/D _113_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X32 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X33 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X34 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X35 _155_/I rebuffer108/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X36 output47/I _089_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X37 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X38 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X39 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X40 _092_/I1 SW0n[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X41 _164_/Z SW1n[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X42 _175_/Z SW1p[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X43 _063_/ZN B[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X44 _065_/ZN B[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X45 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X46 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X47 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X48 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X49 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X50 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X51 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X52 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X53 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X54 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X55 _146_/I _060_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_2
X56 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X57 _143_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__TIEH
X58 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X59 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X60 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X61 _121_/I _114_/A2 _112_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X62 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X63 output22/I _076_/I1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X64 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X65 output22/I SW0p[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X66 _165_/Z SW1n[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X67 output44/I SW1p[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X68 _064_/ZN B[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X69 _066_/ZN B[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X70 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X71 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X72 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X73 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X74 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X75 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X76 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X77 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X78 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X79 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X80 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X81 _111_/I _143_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X82 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X83 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X84 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X85 _155_/Z SW0p[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X86 _166_/Z SW1n[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X87 output45/I SW1p[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X88 _067_/ZN B[9] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X89 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X90 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X91 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X92 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X93 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X94 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X95 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X96 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X97 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X98 _142_/CLK clkload0/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_4
X99 _122_/I _142_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X100 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X101 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X102 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X103 _156_/Z SW0p[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X104 _167_/Z SW1n[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X105 output46/I SW1p[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X106 _145_/Z SW0n[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X107 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X108 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X109 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X110 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X111 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X112 clkbuf_0_CLK/Z _142_/CLK VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_16
X113 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X114 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X115 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X116 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X117 _169_/I _169_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X118 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X119 _146_/Z SW0n[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X120 output25/I SW0p[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X121 _168_/Z SW1n[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X122 output47/I SW1p[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X123 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X124 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X125 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X126 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X127 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X128 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X129 _168_/I _168_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X130 _121_/I _126_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X131 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X132 _147_/Z SW0n[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X133 output26/I SW0p[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X134 _169_/Z SW1n[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X135 output48/I SW1p[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X136 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X137 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X138 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X139 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X140 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X141 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X142 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X143 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X144 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X145 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X146 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X147 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X148 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X149 _167_/I _167_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X150 _111_/I _127_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X151 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X152 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X153 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X154 _148_/Z SW0n[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X155 output27/I SW0p[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X156 output38/I SW1n[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X157 _133_/Q eoc VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X158 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X159 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X160 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X161 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X162 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X163 hold137/Z input1/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X164 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X165 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X166 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X167 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X168 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X169 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X170 _166_/I _166_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X171 _111_/I _128_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X172 _084_/I1 SW0n[4] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X173 output28/I SW0p[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X174 _171_/Z SW1n[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X175 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X176 _162_/I _092_/I1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X177 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X178 input1/Z _121_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X179 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X180 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X181 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X182 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X183 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X184 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X185 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X186 _165_/I _165_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X187 _111_/I _129_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X188 _148_/I _148_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X189 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X190 _086_/I0 SW0n[5] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X191 _161_/Z SW0p[7] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X192 _079_/A1 _175_/I _080_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X193 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X194 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X195 _086_/I1 _092_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X196 max_cap60/I output47/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_8
X197 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X198 _102_/ZN _123_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X199 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X200 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X201 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X202 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X203 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X204 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X205 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X206 _164_/I _164_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X207 _111_/I _130_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X208 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X209 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X210 _147_/I _147_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X211 _078_/I0 wire85/Z _078_/S _130_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X212 _088_/I1 SW0n[6] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X213 _086_/I1 _084_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_2
X214 _155_/I _146_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X215 max_cap61/I output46/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X216 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X217 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X218 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X219 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X220 SAMP hold137/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X221 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X222 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X223 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X224 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X225 _163_/I _163_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X226 _121_/I _131_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X227 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X228 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X229 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X230 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X231 _146_/I _146_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X232 wire68/Z _079_/A1 wire53/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X233 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X234 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X235 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X236 wire85/Z _086_/I1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X237 _156_/I _147_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X238 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X239 _129_/D _129_/RN _117_/Z _142_/CLK _156_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X240 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X241 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X242 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X243 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X244 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X245 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X246 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X247 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X248 _162_/I _162_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X249 _121_/I _114_/A2 _093_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X250 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X251 input1/I input1/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_3
X252 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X253 _145_/I _145_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X254 wire85/Z _076_/I1 _076_/S _131_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X255 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X256 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X257 _148_/I _062_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_8
X258 _168_/I output45/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X259 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X260 _128_/D _128_/RN _116_/Z _143_/CLK _128_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X261 _145_/I _059_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_2
X262 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X263 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X264 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X265 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X266 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X267 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X268 _161_/I _161_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X269 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X270 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X271 _092_/I0 _092_/I1 _092_/S _123_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X272 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X273 Vcomp wire85/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X274 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X275 _075_/A1 wire68/Z _076_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X276 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X277 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X278 _167_/I output44/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X279 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X280 input1/Z _122_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_4
X281 _128_/Q _148_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X282 _127_/D _127_/RN _115_/Z _143_/CLK _127_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X283 _132_/Q _058_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_2
X284 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X285 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X286 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X287 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X288 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X289 _091_/A1 _114_/A2 _092_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X290 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X291 _143_/D _143_/RN _143_/CLK _143_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_1
X292 _074_/I0 _084_/I0 _074_/S _132_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X293 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X294 _121_/I _111_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X295 _063_/I _084_/I1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_8
X296 _126_/D _126_/RN _114_/Z _142_/CLK _126_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X297 _122_/I _132_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X298 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X299 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X300 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X301 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X302 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X303 _122_/I _141_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X304 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X305 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X306 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X307 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X308 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X309 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X310 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X311 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X312 _090_/I0 _092_/I0 _090_/S _124_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X313 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X314 _142_/D _142_/RN _142_/CLK _142_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X315 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X316 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X317 _075_/A1 _133_/Q wire55/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X318 _127_/Q _063_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X319 _166_/I _175_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X320 _125_/D _125_/RN _113_/Z _143_/CLK _125_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X321 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X322 _122_/I _140_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X323 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X324 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X325 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X326 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X327 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X328 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X329 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X330 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X331 _171_/I _141_/RN _143_/CLK _141_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X332 _072_/I _091_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X333 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X334 _126_/Q _086_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X335 max_cap67/I output42/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X336 _142_/D _114_/A2 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X337 _124_/D _124_/RN _112_/Z _142_/CLK _124_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X338 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X339 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X340 _122_/I _139_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X341 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X342 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X343 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X344 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X345 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X346 _140_/D _140_/RN _143_/CLK _140_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X347 _071_/I _087_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X348 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X349 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X350 _125_/Q _088_/I1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X351 _123_/D _123_/RN _093_/Z _142_/CLK _162_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_2
X352 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X353 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X354 _122_/I _138_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X355 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X356 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X357 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X358 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X359 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X360 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X361 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X362 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X363 _070_/I _083_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X364 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X365 _163_/I output40/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X366 _143_/Q _119_/A2 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X367 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X368 _122_/I _134_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X369 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X370 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X371 _122_/I _137_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X372 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X373 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X374 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X375 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X376 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X377 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X378 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X379 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X380 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X381 _142_/Q _171_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X382 _121_/I _133_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X383 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X384 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X385 _122_/I _136_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X386 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X387 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X388 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X389 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X390 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X391 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X392 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X393 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X394 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X395 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X396 _122_/I _142_/D _120_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X397 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X398 _124_/Q _161_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_8
X399 _122_/I _135_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X400 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X401 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X402 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X403 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X404 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X405 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X406 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X407 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X408 Vcomp VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__ANTENNA
X409 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X410 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X411 rebuffer90/I output25/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X412 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X413 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_8
X414 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X415 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X416 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X417 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X418 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X419 _131_/Q _145_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X420 _121_/I _102_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X421 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X422 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X423 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X424 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X425 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X426 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X427 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X428 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X429 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X430 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X431 _131_/Q output22/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X432 CLK clkbuf_0_CLK/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_16
X433 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X434 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X435 _121_/I _124_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X436 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X437 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X438 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X439 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X440 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X441 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X442 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X443 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X444 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X445 _126_/Q _064_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X446 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X447 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X448 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X449 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X450 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X451 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X452 wire50/I _090_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X453 _122_/I _125_/RN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X454 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X455 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X456 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X457 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X458 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X459 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X460 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X461 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X462 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X463 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X464 _126_/Q output27/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X465 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X466 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X467 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X468 wire51/I _086_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X469 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X470 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X471 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X472 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X473 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X474 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X475 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X476 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X477 _125_/Q _065_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X478 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X479 CLK VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__ANTENNA
X480 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X481 _175_/I _175_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X482 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X483 wire52/I _082_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X484 wire85/I wire85/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X485 _089_/A1 _091_/A1 wire50/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X486 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X487 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X488 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X489 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X490 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X491 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X492 _125_/Q output28/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X493 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X494 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X495 _140_/Q max_cap61/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X496 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X497 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X498 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X499 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X500 wire53/I _078_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X501 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X502 _092_/I0 _088_/I1 _088_/S _125_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X503 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X504 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X505 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X506 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X507 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X508 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X509 output44/I _070_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X510 _141_/Q max_cap60/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X511 _156_/I _080_/I1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X512 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X513 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X514 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X515 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X516 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X517 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X518 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X519 wire55/Z _074_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X520 _156_/I _156_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X521 _087_/A1 _089_/A1 _088_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X522 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X523 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X524 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X525 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X526 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X527 _169_/I _139_/RN _143_/CLK _168_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X528 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X529 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X530 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X531 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X532 _124_/Q _066_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X533 output40/I _133_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X534 output38/I _140_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X535 rebuffer99/Z _078_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X536 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X537 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X538 wire55/I wire55/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_1
X539 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X540 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X541 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X542 _155_/I _155_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X543 _086_/I0 _086_/I1 _086_/S _126_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X544 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X545 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X546 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X547 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X548 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X549 _168_/I _138_/RN _143_/CLK _167_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X550 _069_/I _079_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X551 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X552 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X553 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X554 rebuffer101/Z rebuffer99/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X555 _141_/Q output38/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X556 output42/I _069_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X557 _066_/I _090_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X558 _062_/I _082_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X559 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X560 _171_/I _171_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X561 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X562 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X563 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X564 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X565 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X566 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X567 _085_/A1 _087_/A1 wire51/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X568 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X569 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X570 _167_/I _137_/RN _143_/CLK _166_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X571 _133_/D _075_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X572 SAMP VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__ANTENNA
X573 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X574 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X575 rebuffer102/Z rebuffer101/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X576 _162_/I _067_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X577 output48/I _072_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X578 rebuffer99/I rebuffer99/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X579 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X580 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X581 _143_/Q _142_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X582 _164_/I wire68/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X583 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X584 _084_/I0 _084_/I1 _084_/S _127_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X585 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X586 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X587 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X588 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X589 _136_/D _136_/RN _143_/CLK _136_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X590 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X591 _067_/I _067_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_1
X592 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X593 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X594 _111_/I _119_/A2 _119_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X595 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X596 _127_/Q output26/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X597 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X598 rebuffer103/Z rebuffer102/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X599 _142_/Q output48/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X600 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X601 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X602 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X603 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X604 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X605 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X606 _161_/I _152_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X607 _083_/A1 _085_/A1 _084_/S VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NAND2_1
X608 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X609 _165_/I _135_/RN _143_/CLK _164_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X610 _066_/I _066_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_4
X611 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X612 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X613 _111_/I _119_/A2 _118_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X614 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X615 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X616 rebuffer104/Z rebuffer103/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X617 _136_/Q _165_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X618 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X619 _058_/ZN B[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X620 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X621 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X622 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X623 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X624 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X625 _082_/I0 _084_/I0 _082_/S _128_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X626 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X627 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X628 _164_/I _134_/RN _143_/CLK _163_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_2
X629 _065_/I _065_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__INV_2
X630 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X631 _111_/I _119_/A2 _117_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X632 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X633 rebuffer105/Z rebuffer104/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X634 _166_/I _136_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X635 _132_/Q _074_/I0 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X636 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X637 _059_/ZN B[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X638 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X639 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X640 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X641 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X642 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X643 _175_/I _083_/A1 wire52/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__NOR2_1
X644 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X645 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X646 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X647 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X648 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X649 _133_/D _133_/RN _142_/CLK _133_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRNQ_1
X650 _064_/I _064_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_3
X651 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X652 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X653 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X654 _111_/I _143_/Q _116_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X655 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X656 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X657 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X658 rebuffer106/Z rebuffer105/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X659 output45/I _085_/A1 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X660 _136_/Q max_cap67/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X661 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X662 output40/I SW1p[0] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X663 _060_/ZN B[2] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X664 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X665 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X666 clkbuf_0_CLK/Z _143_/CLK VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKBUF_16
X667 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X668 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X669 wire85/Z _080_/I1 _080_/S _129_/D VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__MUX2_2
X670 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X671 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X672 _132_/D _132_/RN _120_/Z _143_/CLK _132_/Q VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__DFFRSNQ_1
X673 _063_/I _063_/ZN VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__CLKINV_4
X674 VDD VSS GF180MCU_FD_SC_MCU7T5V0__ENDCAP
X675 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X676 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_1
X677 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X678 _111_/I _142_/D _115_/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__OR2_1
X679 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILLCAP_4
X680 rebuffer107/Z rebuffer106/Z VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X681 _140_/Q _169_/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X682 _128_/Q rebuffer90/I VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_2
X683 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
X684 _162_/Z SW0p[8] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X685 wire68/Z SW1p[1] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_4
X686 _061_/ZN B[3] VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__BUF_1
X687 VDD VSS GF180MCU_FD_SC_MCU7T5V0__FILLTIE
X688 VDD VDD VSS VSS GF180MCU_FD_SC_MCU7T5V0__FILL_2
*.ends sar_logic


**** end user architecture code
.ends

.end
